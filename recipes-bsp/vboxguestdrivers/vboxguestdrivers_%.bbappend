
COMPATIBLE_MACHINE_append = "|(vbox32|vbox64)"
