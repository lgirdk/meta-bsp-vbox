
RDEPS_WEBKIT_MEDIAPLAYER = "gst-plugins-base-app gst-ffmpeg"

RDEPENDS_${PN} += "\
    ${RDEPS_WEBKIT_MEDIAPLAYER} \
"
